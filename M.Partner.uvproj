# Keil uVision project M.Partner.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: M.Partner +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./Source/: Alarm.c Delay.c Gogogo.c LCD.c Main.c ObstAvoid.c ObstDetect.c ObstInfrared.c SteeringGear.c UltraSonicRanging.c
  group Include
    ./Include/: Alarm.h Delay.h Gogogo.h include.h LCD.h ObstAvoid.h ObstDetect.h ObstInfrared.h SteeringGear.h UltraSonicRanging.h
